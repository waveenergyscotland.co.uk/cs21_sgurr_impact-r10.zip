simulink model "wec4"  (R2016b)
settings: Solver=ode4  StartTime=0  StopTime=1000  FixedStep=0.005  MaxStep=0.005  RelTol=1e-3  EnableMultiTasking=on
values from neighbouring files (symbols this model uses):
  arAdaptiveLawData = 1/2*zModelSimple.zModelPto.arFreq.*     zModelSimple.zModelPto.arMagnitude./     cos(zModelSimple.zModelPto.arPhase*pi/180+pi/2)    [IMPACT_Control.m]
  arAdaptiveLawDataX = 1/2*zModelSimpleX.zModelPto.arFreq.*         zModelSimpleX.zModelPto.arMagnitude./         cos(zModelSimpleX.zModelPto.arPhase*pi/180+pi/2)    [IMPACT_Control.m]
  arControllerRampGain = [0,0,1,1]    [IMPACT_Control.m]
  arControllerRampTime = [0 rStartRampTime rStartRampTime+rRampTimeLength 8000]    [IMPACT_Control.m]
  arEkfInitialisation = zeros(1,11)    [IMPACT_Control.m]
  arEkfInitialisationX = zeros(1,11)    [IMPACT_Control.m]
  arFrequency = zModelSimple.zModelPto.arFreq    [IMPACT_Control.m]
  arFrequencyRange = zModelSimple.zModelPto.arFreq    [IMPACT_Control.m]
  arFrequencyX = zModelSimpleX.zModelPto.arFreq    [IMPACT_Control.m]
  arImpedance = 1./zModelSimple.zModelPto.arMagnitude./zModelSimple.zModelPto.arFreq    [IMPACT_Control.m]
  arImpedanceX = 1./zModelSimpleX.zModelPto.arMagnitude./zModelSimpleX.zModelPto.arFreq    [IMPACT_Control.m]
  CentralPTOPreload = -1.6113e+07    (= -16113000)    [wecSimInputFile.m]
  F1 = [4.243 2.375 -12.243]    [wecSimInputFile.m]
  F2 = [4.243 -2.375 -12.243]    [wecSimInputFile.m]
  F3 = [-4.243 -2.375 -12.243]    [wecSimInputFile.m]
  F4 = [-4.243 2.375 -12.243]    [wecSimInputFile.m]
  FC = [0 0 -14]    [wecSimInputFile.m]
  iAdaptiveDamping = 0    [wec4IMPACT_Project.m]    (also in IMPACT_Control.m = handles.iAdaptiveDamping; wec1_IMPACT_Project.m; wec2_IMPACT_Project.m; wec3_IMPACT_Project.m)
  iControlType = 2    [wec4IMPACT_Project.m]    (also in IMPACT_Control.m = handles.iControlType; wec1_IMPACT_Project.m = 1; wec2_IMPACT_Project.m = 1; wec3_IMPACT_Project.m = 1)
  iPtoPositionConstraint = 1    [wec4IMPACT_Project.m]    (also in IMPACT_Control.m = handles.iPtoPositionConstraint; wec1_IMPACT_Project.m = 0; wec2_IMPACT_Project.m; wec3_IMPACT_Project.m)
  iSensorNoise = 0    [IMPACT_Control.m]
  m = m+1    (= 2)    [checkParamFile.m]
  PTOrotation = atan((T1(2)-F1(2))/(T1(1)-F1(1)))    [wecSimInputFile.m]
  rCogFloater = -8    [wec4_IMPACT_Model.m]    (also in paramInitial.m = get( handles.edit_rCogFloater, 'String' ); wec1_IMPACT_Model.m = -18; wec2_IMPACT_Model.m = -8.5; wec3_IMPACT_Model.m = -0.7)
  rCogSpar = -36.6    [wec4_IMPACT_Model.m]    (also in paramInitial.m = get( handles.edit_rCogSpar, 'String' ); wec3_IMPACT_Model.m = -21.3; wec3_IMPACT_Model2.m = -21.3)
  rDisplacementLimit = 10.000000    (= 10)    [wec4IMPACT_Project.m]    (also in IMPACT_Control.m = getValue(handles.edit_displacementLimit); wec1_IMPACT_Project.m; wec2_IMPACT_Project.m; wec3_IMPACT_Project.m = 3)
  rDisplacementLimitX = 10.000000    (= 10)    [wec4IMPACT_Project.m]    (also in IMPACT_Control.m = getValue(handles.edit_displacementLimitX); wec1_IMPACT_Project.m = 0; wec2_IMPACT_Project.m; wec3_IMPACT_Project.m = 0)
  rGainForAntiWIndUp = tfControllerDiscrete.rGain    [IMPACT_Control.m]
  rGainForAntiWIndUpX = tfControllerXDiscrete.rGain    [IMPACT_Control.m]
  rMaxForcePto = 300000000.000000    (= 300000000)    [wec4IMPACT_Project.m]    (also in IMPACT_Control.m = getValue(handles.edit_maxForcePto); wec1_IMPACT_Project.m = 1e+15; wec2_IMPACT_Project.m = 1e+15; wec3_IMPACT_Project.m = 1000000000)
  rMinForcePto = -300000000.000000    (= -300000000)    [wec4IMPACT_Project.m]    (also in IMPACT_Control.m = getValue(handles.edit_minForcePto); wec1_IMPACT_Project.m = -1e+15; wec2_IMPACT_Project.m = -1e+15; wec3_IMPACT_Project.m = -1000000000)
  rMooringX = 20000    [wec4_IMPACT_Model.m]    (also in paramInitial.m = get( handles.edit_rMooringX, 'String' ); wec3_IMPACT_Model.m = 10000; wec3_IMPACT_Model2.m = 10000)
  rMooringZ = 10000    [wec4_IMPACT_Model.m]    (also in paramInitial.m = get( handles.edit_rMooringZ, 'String' ); wec3_IMPACT_Model.m = 0; wec3_IMPACT_Model2.m = 0)
  rOutputSampleTime = 0.010000    (= 0.01)    [wec4IMPACT_Project.m]    (also in IMPACT_Control.m = getValue(handles.edit_outputSampleTime); wec1_IMPACT_Project.m; wec2_IMPACT_Project.m; wec3_IMPACT_Project.m)
  rPassiveDampingGain = -604830.000000    (= -604830)    [wec4IMPACT_Project.m]    (also in IMPACT_Control.m = getValue(handles.edit_gainPLD); wec1_IMPACT_Project.m = -214018.1537; wec2_IMPACT_Project.m = -1948070; wec3_IMPACT_Project.m = -519390)
  rPassiveDampingGainX = -278660.000000    (= -278660)    [wec4IMPACT_Project.m]    (also in IMPACT_Control.m = getValue(handles.edit_gainPLDX); wec1_IMPACT_Project.m = 0; wec2_IMPACT_Project.m = 0; wec3_IMPACT_Project.m = 0)
  rTetherPretension = 1.6113e+07    (= 16113000)    [wec4_IMPACT_Model.m]    (also in paramInitial.m = get( handles.edit_rTetherPretension, 'String' ); wec3_IMPACT_Model.m = 0; wec3_IMPACT_Model2.m = 0)
  rTetherSpring = 500000    [wec4_IMPACT_Model.m]    (also in paramInitial.m = get( handles.edit_rTetherSpring, 'String' ); wec3_IMPACT_Model.m = 0; wec3_IMPACT_Model2.m = 0)
  rUpperFrequencyLimit = EKFFloater.upperFreq    [IMPACT_Control.m]
  rXf = 4.243    [wec4AdditionalParams.m]
  rXs = 16.075    [wec4AdditionalParams.m]
  rYf = 2.375    [wec4AdditionalParams.m]
  rYs = 16.075    [wec4AdditionalParams.m]
  rZf = 4.243    [wec4AdditionalParams.m]
  rZs = 2.4350    (= 2.435)    [wec4AdditionalParams.m]
  rZTetherF = 6    [wec4AdditionalParams.m]
  rZTetherS = 2.4350    (= 2.435)    [wec4AdditionalParams.m]
  s = tf('s')    [wec4_IMPACT_Model.m]    (also in IMPACT_Control.m; wec1_IMPACT_Model.m; wec2_IMPACT_Model.m; wec3_IMPACT_Model.m)
  SidePTO1Preload = PreloadPTOCorner    (= 0)    [wecSimInputFile.m]
  SidePTO2Preload = PreloadPTOCorner    (= 0)    [wecSimInputFile.m]
  SidePTO3Preload = PreloadPTOCorner    (= 0)    [wecSimInputFile.m]
  SidePTO4Preload = PreloadPTOCorner    (= 0)    [wecSimInputFile.m]
  simu = simulationClass()    [wecSimInputFile.m]
  T1 = [16.075 16.075 -34.165]    [wecSimInputFile.m]
  T2 = [16.075 -16.075 -34.165]    [wecSimInputFile.m]
  T3 = [-16.075 -16.075 -34.165]    [wecSimInputFile.m]
  T4 = [-16.075 16.075 -34.165]    [wecSimInputFile.m]
  TC = [0 0 -34.165]    [wecSimInputFile.m]
  waves = waveClass('irregular')    [wecSimInputFile.m]
  Z = magPhaseToComplex(zModelTf)    [IMPACT_Control.m]
undefined symbols (not defined in the file or in its folder): arControllerDiscreteDen, arControllerDiscreteNum, arControllerDiscreteXDen, arControllerDiscreteXNum, arExcForceFloaterDen, arExcForceFloaterNum, arExcForceFloaterXDen, arExcForceFloaterXNum, arExcForceSparDen, arExcForceSparNum, arExcForceSparXDen, arExcForceSparXNum, arFexcFloaterDen, arFexcFloaterNum, arFexcFloaterXDen, arFexcFloaterXNum, arFexcSparDen, arFexcSparNum, arFexcSparXDen, arFexcSparXNum, Body, body, constraint, CTTime, deg, Elements, geometry, IRKB, kg, lenJ, mooring, N, pto, rAccelerationGainFloater, rAccelerationGainFloaterX, rAccelerationGainSpar, rAccelerationGainSparX, rad, rBuoyancyGainFloater, rBuoyancyGainFloaterX, rBuoyancyGainSpar, rBuoyancyGainSparX, rDampingGainFloater, rDampingGainFloaterX, rDampingGainSpar, rDampingGainSparX, Rigid, rMaxFocePto, wec4_float, wec4_reactor, WECSim_Lib, X, Y
libraries: nesl_utility x380, sm_lib x170, vrlib x91, simulink x12, WECSim_Lib x4
(part 24 of 26)

== system wec4/PTO P3F3/PTO P3F3 visu/Hydrodynamic Body/Morrison Element and ViscousDampingForceCalculation/Morrison Element Variant Subsystem/Morrison Element On/No Wave Morison Force/MorrisonElements/OrbitalVelocity/No Ramp Function ==
  Ain : Inport
  Action Port : ActionPort
  Aout : Outport
  wires:
  Ain/1 -> Aout/1

== system wec4/PTO P4F4/PTO P4F4 visu/Hydrodynamic Body/Morrison Element and ViscousDampingForceCalculation/Morrison Element Variant Subsystem/Morrison Element On/No Wave Morison Force/MorrisonElements/OrbitalVelocity/Applied Ramp Function ==
  Ain : Inport
  Action Port : ActionPort
  Add : Sum
  Constant : Constant  Value=2
  Constant1 : Constant
  Divide : Product  Inputs=**/
  Sine Wave : Sin  Frequency=pi/simu.rampTime  Phase=pi+pi/2  SampleTime=0
  Aout : Outport
  wires:
  Add/1 -> Divide/2
  Sine Wave/1 -> Add/2
  Constant1/1 -> Add/1
  Constant/1 -> Divide/3
  Divide/1 -> Aout/1
  Ain/1 -> Divide/1

== system wec4/PTO P4F4/PTO P4F4 visu/Hydrodynamic Body/Morrison Element and ViscousDampingForceCalculation/Morrison Element Variant Subsystem/Morrison Element On/No Wave Morison Force/MorrisonElements/OrbitalVelocity/No Ramp Function ==
  Ain : Inport
  Action Port : ActionPort
  Aout : Outport
  wires:
  Ain/1 -> Aout/1

== matlab function wec4/EKFs/EKF1 ==
function [rPhi0Output,rPhi0StarOutput,rFrequencyOutput, rAmplitudeOutput] =...
    kalmanFilter(rEstimatedExcitationForce,arEkfInitialisation)
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%
%%%                     Extended Kalman Filter                        %%%

%-----------------------------
% State equations
% X[n+1] = A*X[n] + B*U[n] + v
% Output equation
% Y[n] = C*X[n] + e
%-----------------------------
% n = Nº States
% m = Nº of inputs
% p = Nº of outputs
%
% See the IMPACT Deliverable 4 report for more detail on derivation of the
% Extended Kalman Filter
%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%

% Matrices of the system: A, B, C

persistent A B C P_k_k R1 R2 X_k_k bInit rFrequency rTimeStep rPhi0 rPhi0Star 
% On the first step bInit is empty and so the initialisation can run

if isempty(bInit)
    
    bInit = 1;
    rFrequency = arEkfInitialisation(1);%0.5;
    rPhi0 = arEkfInitialisation(2);%1e5;
    rPhi0Star = arEkfInitialisation(3);%0;
    rTimeStep = arEkfInitialisation(4);
    
    A = zeros(3);
    A(1,:) = [cos(rFrequency*rTimeStep), sin(rFrequency*rTimeStep),...
        (-sin(rFrequency*rTimeStep)*rPhi0+cos(rFrequency*rTimeStep)*rPhi0Star)*rTimeStep];
    A(2,:) = [-sin(rFrequency*rTimeStep), cos(rFrequency*rTimeStep),...
        (-cos(rFrequency*rTimeStep)*rPhi0-sin(rFrequency*rTimeStep)*rPhi0Star)*rTimeStep];
    A(3,3) = 1;
    
    B = ones(3,1);
    C = zeros(1,3);
    C(1)=1;
    

%     % Process noise covariance matrix
    R1 = [arEkfInitialisation(5),0,0;...
        0,arEkfInitialisation(6),0;...
        0,0,arEkfInitialisation(7)];
% 
%     % Measurement Noise covariance matrix
    R2 = arEkfInitialisation(8);
        

    P_k_k =  [arEkfInitialisation(9),0,0;...
        0,arEkfInitialisation(10),0;...
        0,0,arEkfInitialisation(11)];
    X_k_k = [rPhi0,rPhi0Star,rFrequency]';
    

end % End of initialisation

% No "input" for this EKF
U = 0;

% Time step consistent with simulation
rTimeStep = arEkfInitialisation(4);

% Define the A matrix as per deliverable 4 report
A(1,:) = [cos(rFrequency*rTimeStep) sin(rFrequency*rTimeStep) 0];
A(2,:) = [-sin(rFrequency*rTimeStep) cos(rFrequency*rTimeStep) 0];
A(3,3) = 1;


% Define the Jacobian as per deliverable 4 report - Note that for very
% small frequencies infinity must be avoided
JA = zeros(3);

if rFrequency<0.001 & rFrequency>=-0.001
    JA(1,:) = [cos(rFrequency*rTimeStep) sin(rFrequency*rTimeStep) rPhi0Star*rTimeStep-rPhi0*rFrequency*rTimeStep^2/2];
    JA(2,:) = [-sin(rFrequency*rTimeStep) cos(rFrequency*rTimeStep) -rPhi0*rTimeStep-rPhi0Star*rFrequency*rTimeStep^2/2];
    JA(3,3) = 1;
else
    JA(1,:) = [cos(rFrequency*rTimeStep) sin(rFrequency*rTimeStep) rPhi0Star*sin(rFrequency*rTimeStep)/rFrequency-rPhi0*(1-cos(rFrequency*rTimeStep))/rFrequency];
    JA(2,:) = [-sin(rFrequency*rTimeStep) cos(rFrequency*rTimeStep) -rPhi0*sin(rFrequency*rTimeStep)/rFrequency-rPhi0Star*(1-cos(rFrequency*rTimeStep))/rFrequency];
    JA(3,3) = 1;
end

% Define B and C Matrices
B = ones(3,1);
C = zeros(1,3);
C(1)=1;

% Kalman Filter
%---------------------------------
% Prediction
X_k1_k = A*X_k_k + B*U;

P_k1_k = JA*P_k_k*JA' + R1;

% Filter
Kf = P_k1_k*C'/(C*P_k1_k*C' + R2);
X_k1_k1 = X_k1_k + Kf*(rEstimatedExcitationForce-C*X_k1_k);
P_k1_k1 = P_k1_k - Kf*(C*P_k1_k*C'+R2)*Kf';


P_k_k = P_k1_k1; % for next cycle;
X_k_k = X_k1_k1; % for next cycle;

rFrequency = X_k_k(3);
rPhi0 = X_k_k(1);
rPhi0Star = X_k_k(2);

rFrequencyOutput = X_k_k(3);
rPhi0Output = X_k_k(1);
rPhi0StarOutput = X_k_k(2);

rAmplitudeOutput = sqrt(rPhi0.^2+rPhi0Star.^2);

== matlab function wec4/Float/Hydrodynamic Body/Hydrostatic Restoring Force Calculation/Linear and Nonlinear Restoring Force Variant Subsystem/Nonlinear Hydrostatic Restoring Force/Restoring Forces ==
function [f,p]  = nonLinearBuoyancy(x,elv,center,tnorm,area,rho,g,cg,mass)
% Function to calculate buoyancy force and moment on a triangulated surface
% NOTE: This function assumes that the STL file is imported with its CG at 0,0,0
[f,p] = calc_buoyancy(x,elv,center,tnorm,area,rho,g,cg);
f = -f + [0 0 g*mass 0 0 0]';
end


function [f,p] = calc_buoyancy(x,elv,center,tnorm,area,rho,g,cg)
% Function to apply translation and rotation and calculate forces

% Compute new tri coords after cog rotation and translation
center = rotateXYZ(center,[1 0 0],x(4));
center = rotateXYZ(center,[0 1 0],x(5));
center = rotateXYZ(center,[0 0 1],x(6));
center = offsetXYZ(center,x);
center = offsetXYZ(center,cg);
% Compute new normal vectors coords after cog rotation
tnorm = rotateXYZ(tnorm,[1 0 0],x(4));
tnorm = rotateXYZ(tnorm,[0 1 0],x(5));
tnorm = rotateXYZ(tnorm,[0 0 1],x(6));

% Calculate the hydrostatic forces
av = tnorm .* [area area area];
[f,p]=fHydrostatic(center,elv,x(1:3)+cg,av,rho,g);
end

function verts = offsetXYZ(verts,x)
% Function to move the position vertices
verts(:,1) = verts(:,1) + x(1);
verts(:,2) = verts(:,2) + x(2);
verts(:,3) = verts(:,3) + x(3);
end

function xn = rotateXYZ(x,ax,t)
% Function to rotate a point about an arbitrary axis
% x: 3-componenet coordiantes
% ax: axis about which to rotate (must be a vector length 1)
% t: rotation angle
% xn: new coordinates after rotation
rotMat = zeros(3);
rotMat(1,1) = ax(1)*ax(1)*(1-cos(t))    + cos(t);
rotMat(1,2) = ax(2)*ax(1)*(1-cos(t))    + ax(3)*sin(t);
rotMat(1,3) = ax(3)*ax(1)*(1-cos(t))    - ax(2)*sin(t);
rotMat(2,1) = ax(1)*ax(2)*(1-cos(t))    - ax(3)*sin(t);
rotMat(2,2) = ax(2)*ax(2)*(1-cos(t))    + cos(t);
rotMat(2,3) = ax(3)*ax(2)*(1-cos(t))    + ax(1)*sin(t);
rotMat(3,1) = ax(1)*ax(3)*(1-cos(t))    + ax(2)*sin(t);
rotMat(3,2) = ax(2)*ax(3)*(1-cos(t))    - ax(1)*sin(t);
rotMat(3,3) = ax(3)*ax(3)*(1-cos(t))    + cos(t);
xn = x*rotMat;
end

function [f,p] = fHydrostatic(center,elv,instcg,av,rho,g)
% Function to calculate the force and moment about the cog due to hydrostatic pressure
f = zeros(6,1);

% Zeor out regions above the mean free surface
z=center(:,3); z((z-elv)>0)=0;

% Calculate the hydrostatic pressure at each triangle center
pressureVect = rho*g.*[-z -z -z].*-av;
p = rho*g.*-z;
% Compute force about cog
f(1:3) = sum(pressureVect);

tmp1 = ones(length(center(:,1)),1);
tmp2 = tmp1*instcg';
center2cgVec = center-tmp2;

f(4:6)= sum(cross(center2cgVec,pressureVect));
end

== matlab function wec4/EKFs/EKF ==
function [rPhi0Output,rPhi0StarOutput,rFrequencyOutput, rAmplitudeOutput] = ...
    kalmanFilter(rEstimatedExcitationForce,arEkfInitialisation)

%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%
%%%                     Extended Kalman Filter                        %%%
%-----------------------------
% State equations
% X[n+1] = A*X[n] + B*U[n] + v
% Output equation
% Y[n] = C*X[n] + e
%-----------------------------
% n = Nº States
% m = Nº of inputs
% p = Nº of outputs
%
% See the IMPACT Deliverable 4 report for more detail on derivation of the
% Extended Kalman Filter
%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%

% Matrices of the system: A, B, C

persistent A B C P_k_k R1 R2 X_k_k bInit rFrequency rTimeStep rPhi0 rPhi0Star 

% On the first step bInit is empty and so the initialisation can run

if isempty(bInit)
    
    bInit = 1;
    rFrequency = arEkfInitialisation(1);%0.5;
    rPhi0 = arEkfInitialisation(2);%1e5;
    rPhi0Star = arEkfInitialisation(3);%0;
    rTimeStep = arEkfInitialisation(4);
    
    A = zeros(3);
    A(1,:) = [cos(rFrequency*rTimeStep), sin(rFrequency*rTimeStep),...
        (-sin(rFrequency*rTimeStep)*rPhi0+cos(rFrequency*rTimeStep)*rPhi0Star)*rTimeStep];
    A(2,:) = [-sin(rFrequency*rTimeStep), cos(rFrequency*rTimeStep),...
        (-cos(rFrequency*rTimeStep)*rPhi0-sin(rFrequency*rTimeStep)*rPhi0Star)*rTimeStep];
    A(3,3) = 1;
    
    B = ones(3,1);
    C = zeros(1,3);
    C(1)=1;
   

    % Process noise covariance matrix
    R1 = [arEkfInitialisation(5),0,0;...
        0,arEkfInitialisation(6),0;...
        0,0,arEkfInitialisation(7)];
 
    % Measurement Noise covariance matrix
    R2 = arEkfInitialisation(8);
    
    P_k_k =  [arEkfInitialisation(9),0,0;...
        0,arEkfInitialisation(10),0;...
        0,0,arEkfInitialisation(11)];
    X_k_k = [rPhi0,rPhi0Star,rFrequency]';
    

end % End of initialisation

% No "input" for this EKF
U = 0;

% Time step consistent with simulation
rTimeStep = arEkfInitialisation(4);

% Define the A matrix as per deliverable 4 report
A(1,:) = [cos(rFrequency*rTimeStep) sin(rFrequency*rTimeStep) 0];
A(2,:) = [-sin(rFrequency*rTimeStep) cos(rFrequency*rTimeStep) 0];
A(3,3) = 1;


% Define the Jacobian as per deliverable 4 report - Note that for very
% small frequencies infinity must be avoided
JA = zeros(3);

if rFrequency<0.001 & rFrequency>=-0.001
    JA(1,:) = [cos(rFrequency*rTimeStep) sin(rFrequency*rTimeStep) rPhi0Star*rTimeStep-rPhi0*rFrequency*rTimeStep^2/2];
    JA(2,:) = [-sin(rFrequency*rTimeStep) cos(rFrequency*rTimeStep) -rPhi0*rTimeStep-rPhi0Star*rFrequency*rTimeStep^2/2];
    JA(3,3) = 1;
else
    JA(1,:) = [cos(rFrequency*rTimeStep) sin(rFrequency*rTimeStep) rPhi0Star*sin(rFrequency*rTimeStep)/rFrequency-rPhi0*(1-cos(rFrequency*rTimeStep))/rFrequency];
    JA(2,:) = [-sin(rFrequency*rTimeStep) cos(rFrequency*rTimeStep) -rPhi0*sin(rFrequency*rTimeStep)/rFrequency-rPhi0Star*(1-cos(rFrequency*rTimeStep))/rFrequency];
    JA(3,3) = 1;
end

% Define B and C Matrices
B = ones(3,1);
C = zeros(1,3);
C(1)=1;

% Kalman Filter
%---------------------------------
% Prediction
X_k1_k = A*X_k_k + B*U;

P_k1_k = JA*P_k_k*JA' + R1;

% Filter
Kf = P_k1_k*C'/(C*P_k1_k*C' + R2);
X_k1_k1 = X_k1_k + Kf*(rEstimatedExcitationForce-C*X_k1_k);
P_k1_k1 = P_k1_k - Kf*(C*P_k1_k*C'+R2)*Kf';


P_k_k = P_k1_k1; % for next cycle;
X_k_k = X_k1_k1; % for next cycle;


rFrequency = X_k_k(3);
rPhi0 = X_k_k(1);
rPhi0Star = X_k_k(2);

rFrequencyOutput = X_k_k(3);
rPhi0Output = X_k_k(1);
rPhi0StarOutput = X_k_k(2);

rAmplitudeOutput = sqrt(rPhi0.^2+rPhi0Star.^2);

== matlab function wec4/Float/Hydrodynamic Body/Morrison Element and ViscousDampingForceCalculation/Morrison Element Variant Subsystem/Morrison Element On/Irregular Wave 
Morison Force/MorrisonElements/MorisonElementIrregular/MATLAB Function ==
function [u,v,w,xa,ya,za] = calc_orbital_vel(disp, waveNumber, waveFreq, waveAmp, phase, time, rampT, waveDir, waterDepth, g)
%#codegen

[u,v,w,xa,ya,za] = orbital_velocity(disp, waveNumber, waveFreq, waveAmp, phase, time, rampT, waveDir, waterDepth, g);

== matlab function wec4/Float/Hydrodynamic Body/Wave Radiation Forces Calculation/SS CI and Constant-Damping-CoeVariant Subsystem/Convolution Integral Calculation/MATLAB Function ==
function F_FM = ConvolutionIntegral_interp(v, IRKB, lenJ, CTTime)
%#codegen
% Function to calculate convolution integral

%define persistent variables
interp_factor = 1;
persistent velocity IRKB_interp CTTime_interp;

if isempty(velocity) 
    CTTime_interp  = CTTime(1:interp_factor:end);
    velocity       = zeros(lenJ,length(CTTime_interp));
    IRKB_reordered = permute(IRKB,[3 1 2]);                     % permutes from [601 6 12] to [12 601 6]
    IRKB_interp    = IRKB_reordered(:,1:interp_factor:end, :);  % what does this do?
end 
% shift velocity
velocity      = circshift(velocity, 1, 2);
v = v(:)'';           %force v to be a column
velocity(:,1) = v(:);

%integrate
time_series = bsxfun(@times, IRKB_interp, velocity);
F_FM = squeeze(trapz(CTTime_interp,sum(time_series, 1)));

end

== matlab function wec4/Reactor/Hydrodynamic Body/Hydrostatic Restoring Force Calculation/Linear and Nonlinear Restoring Force Variant Subsystem/Nonlinear Hydrostatic Restoring Force/Restoring Forces ==
function [f,p]  = nonLinearBuoyancy(x,elv,center,tnorm,area,rho,g,cg,mass)
% Function to calculate buoyancy force and moment on a triangulated surface
% NOTE: This function assumes that the STL file is imported with its CG at 0,0,0
[f,p] = calc_buoyancy(x,elv,center,tnorm,area,rho,g,cg);
f = -f + [0 0 g*mass 0 0 0]';
end


function [f,p] = calc_buoyancy(x,elv,center,tnorm,area,rho,g,cg)
% Function to apply translation and rotation and calculate forces

% Compute new tri coords after cog rotation and translation
center = rotateXYZ(center,[1 0 0],x(4));
center = rotateXYZ(center,[0 1 0],x(5));
center = rotateXYZ(center,[0 0 1],x(6));
center = offsetXYZ(center,x);
center = offsetXYZ(center,cg);
% Compute new normal vectors coords after cog rotation
tnorm = rotateXYZ(tnorm,[1 0 0],x(4));
tnorm = rotateXYZ(tnorm,[0 1 0],x(5));
tnorm = rotateXYZ(tnorm,[0 0 1],x(6));

% Calculate the hydrostatic forces
av = tnorm .* [area area area];
[f,p]=fHydrostatic(center,elv,x(1:3)+cg,av,rho,g);
end

function verts = offsetXYZ(verts,x)
% Function to move the position vertices
verts(:,1) = verts(:,1) + x(1);
verts(:,2) = verts(:,2) + x(2);
verts(:,3) = verts(:,3) + x(3);
end

function xn = rotateXYZ(x,ax,t)
% Function to rotate a point about an arbitrary axis
% x: 3-componenet coordiantes
% ax: axis about which to rotate (must be a vector length 1)
% t: rotation angle
% xn: new coordinates after rotation
rotMat = zeros(3);
rotMat(1,1) = ax(1)*ax(1)*(1-cos(t))    + cos(t);
rotMat(1,2) = ax(2)*ax(1)*(1-cos(t))    + ax(3)*sin(t);
rotMat(1,3) = ax(3)*ax(1)*(1-cos(t))    - ax(2)*sin(t);
rotMat(2,1) = ax(1)*ax(2)*(1-cos(t))    - ax(3)*sin(t);
rotMat(2,2) = ax(2)*ax(2)*(1-cos(t))    + cos(t);
rotMat(2,3) = ax(3)*ax(2)*(1-cos(t))    + ax(1)*sin(t);
rotMat(3,1) = ax(1)*ax(3)*(1-cos(t))    + ax(2)*sin(t);
rotMat(3,2) = ax(2)*ax(3)*(1-cos(t))    - ax(1)*sin(t);
rotMat(3,3) = ax(3)*ax(3)*(1-cos(t))    + cos(t);
xn = x*rotMat;
end

function [f,p] = fHydrostatic(center,elv,instcg,av,rho,g)
% Function to calculate the force and moment about the cog due to hydrostatic pressure
f = zeros(6,1);

% Zeor out regions above the mean free surface
z=center(:,3); z((z-elv)>0)=0;

% Calculate the hydrostatic pressure at each triangle center
pressureVect = rho*g.*[-z -z -z].*-av;
p = rho*g.*-z;
% Compute force about cog
f(1:3) = sum(pressureVect);

tmp1 = ones(length(center(:,1)),1);
tmp2 = tmp1*instcg';
center2cgVec = center-tmp2;

f(4:6)= sum(cross(center2cgVec,pressureVect));
end

== matlab function wec4/Reactor/Hydrodynamic Body/Morrison Element and ViscousDampingForceCalculation/Morrison Element Variant Subsystem/Morrison Element On/Irregular Wave 
Morison Force/MorrisonElements/MorisonElementIrregular/MATLAB Function ==
function [u,v,w,xa,ya,za] = calc_orbital_vel(disp, waveNumber, waveFreq, waveAmp, phase, time, rampT, waveDir, waterDepth, g)
%#codegen

[u,v,w,xa,ya,za] = orbital_velocity(disp, waveNumber, waveFreq, waveAmp, phase, time, rampT, waveDir, waterDepth, g);

== matlab function wec4/Reactor/Hydrodynamic Body/Morrison Element and ViscousDampingForceCalculation/Morrison Element Variant Subsystem/Morrison Element On/Regular Wave 
Morison Force/MorrisonElements/OrbitalVelocity/MATLAB Function ==
function [u,v,w,xa,ya,za] = calc_orbital_vel(disp, waveNumber, waveFreq, waveAmp, randPhase, time, rampT, waveDir, waterDepth, g)
%#codegen

[u,v,w,xa,ya,za] = orbital_velocity(disp, waveNumber, waveFreq, waveAmp, randPhase, time, rampT, waveDir, waterDepth, g);

== matlab function wec4/Reactor/Hydrodynamic Body/Nonlinear Wave Elevation/Linear or Instantaneous Free Surface/Instantaneous Water Free Surface  /Instantaneous FS ==
function f  = waveElevation(x,center,cg,AH,w,dw,k,typeNum,t,rampT,phaseRand,waveDir)
% Function to calculate the wave elevation at the ceontroids of triangulated surface
% NOTE: This function assumes that the STL file is imported with its CG at 0,0,0
f = calc_elev(x,center,cg,AH,w,dw,k,typeNum,t,rampT,phaseRand, waveDir);
end

function f = calc_elev(x,center,cg,AH,w,dw,k,typeNum,t,rampT,phaseRand,waveDir)
% Function to rotate and translate body and call wave elevation function at new locations

% Compute new tri center coords after cog rotation and translation
center = rotateXYZ(center,[1 0 0],x(4));
center = rotateXYZ(center,[0 1 0],x(5));
center = rotateXYZ(center,[0 0 1],x(6));
center = offsetXYZ(center,x);
center = offsetXYZ(center,cg);
% Calculate the free surface
f=waveElev(center,AH,w,dw,t,k,rampT,phaseRand,typeNum,waveDir);
end

function verts = offsetXYZ(verts,x)
% Function to move the position vertices
verts(:,1) = verts(:,1) + x(1);
verts(:,2) = verts(:,2) + x(2);
verts(:,3) = verts(:,3) + x(3);
end

function xn = rotateXYZ(x,ax,t)
% Function to rotate a point about an arbitrary axis
% x: 3-component coordinates
% ax: axis about which to rotate (must be a vector length 1)
% t: rotation angle
% xn: new coordinates after rotation
rotMat = zeros(3);
rotMat(1,1) = ax(1)*ax(1)*(1-cos(t))    + cos(t);
rotMat(1,2) = ax(2)*ax(1)*(1-cos(t))    + ax(3)*sin(t);
rotMat(1,3) = ax(3)*ax(1)*(1-cos(t))    - ax(2)*sin(t);
rotMat(2,1) = ax(1)*ax(2)*(1-cos(t))    - ax(3)*sin(t);
rotMat(2,2) = ax(2)*ax(2)*(1-cos(t))    + cos(t);
rotMat(2,3) = ax(3)*ax(2)*(1-cos(t))    + ax(1)*sin(t);
rotMat(3,1) = ax(1)*ax(3)*(1-cos(t))    + ax(2)*sin(t);
rotMat(3,2) = ax(2)*ax(3)*(1-cos(t))    - ax(1)*sin(t);
rotMat(3,3) = ax(3)*ax(3)*(1-cos(t))    + cos(t);
xn = x*rotMat;
end

function f=waveElev(center,AH,w,dw,t,k,rampT,phaseRand,typeNum,waveDir)
% Function to calculate the wave elevation at an array of points
f = zeros(length(center(:,3)),1);
cx = center(:,1);
cy = center(:,2);
X = cx*cos(waveDir*pi/180) + cy*sin(waveDir*pi/180);
if typeNum <10
elseif typeNum <20
    f = AH(1).*cos(k(1).*X-w(1)*t);
elseif typeNum <30
    tmp=sqrt(AH.*dw);
    tmp1 = ones(1,length(center(:,1)));
    tmp2 = (w.*t+phaseRand)*tmp1;
    tmp3 = cos(k*X'- tmp2);
    f(:,1) = tmp3'*tmp;
end
if t<=rampT
    rampF = (1+cos(pi+pi*t/rampT))/2;
    f = f.*rampF;
end
end

== matlab function wec4/Float/Hydrodynamic Body/Morrison Element and ViscousDampingForceCalculation/Morrison Element Variant Subsystem/Morrison Element On/Regular Wave 
Morison Force/MorrisonElements/OrbitalVelocity/MATLAB Function ==
function [u,v,w,xa,ya,za] = calc_orbital_vel(disp, waveNumber, waveFreq, waveAmp, randPhase, time, rampT, waveDir, waterDepth, g)
%#codegen

[u,v,w,xa,ya,za] = orbital_velocity(disp, waveNumber, waveFreq, waveAmp, randPhase, time, rampT, waveDir, waterDepth, g);

== matlab function wec4/Reactor/Hydrodynamic Body/Structure/Motion Sensor/Angle ==
function E  = EulerAngle(Q)
% Euler Angle Type II or Tait-Bryan Angle for sequence 321 or zyx (Nautical or Cardan angles).
% Yaw [-180,180], followed by pitch [-90,90], followed by roll [-180,180]
E = zeros(3,1);
E(1) = atan2((2*(Q(1)*Q(2)+Q(3)*Q(4))),(1-2*(Q(2)^2+Q(3)^2)));
E(2) = asin(2*(Q(1)*Q(3)-Q(4)*Q(2)));
E(3) = atan2((2*(Q(1)*Q(4)+Q(2)*Q(3))),(1-2*(Q(3)^2+Q(4)^2)));

== matlab function wec4/Float/Hydrodynamic Body/Nonlinear Wave Elevation/Linear or Instantaneous Free Surface/Instantaneous Water Free Surface  /Instantaneous FS ==
function f  = waveElevation(x,center,cg,AH,w,dw,k,typeNum,t,rampT,phaseRand,waveDir)
% Function to calculate the wave elevation at the ceontroids of triangulated surface
% NOTE: This function assumes that the STL file is imported with its CG at 0,0,0
f = calc_elev(x,center,cg,AH,w,dw,k,typeNum,t,rampT,phaseRand, waveDir);
end

function f = calc_elev(x,center,cg,AH,w,dw,k,typeNum,t,rampT,phaseRand,waveDir)
% Function to rotate and translate body and call wave elevation function at new locations

% Compute new tri center coords after cog rotation and translation
center = rotateXYZ(center,[1 0 0],x(4));
center = rotateXYZ(center,[0 1 0],x(5));
center = rotateXYZ(center,[0 0 1],x(6));
center = offsetXYZ(center,x);
center = offsetXYZ(center,cg);
% Calculate the free surface
f=waveElev(center,AH,w,dw,t,k,rampT,phaseRand,typeNum,waveDir);
end

function verts = offsetXYZ(verts,x)
% Function to move the position vertices
verts(:,1) = verts(:,1) + x(1);
verts(:,2) = verts(:,2) + x(2);
verts(:,3) = verts(:,3) + x(3);
end

function xn = rotateXYZ(x,ax,t)
% Function to rotate a point about an arbitrary axis
% x: 3-component coordinates
% ax: axis about which to rotate (must be a vector length 1)
% t: rotation angle
% xn: new coordinates after rotation
rotMat = zeros(3);
rotMat(1,1) = ax(1)*ax(1)*(1-cos(t))    + cos(t);
rotMat(1,2) = ax(2)*ax(1)*(1-cos(t))    + ax(3)*sin(t);
rotMat(1,3) = ax(3)*ax(1)*(1-cos(t))    - ax(2)*sin(t);
rotMat(2,1) = ax(1)*ax(2)*(1-cos(t))    - ax(3)*sin(t);
rotMat(2,2) = ax(2)*ax(2)*(1-cos(t))    + cos(t);
rotMat(2,3) = ax(3)*ax(2)*(1-cos(t))    + ax(1)*sin(t);
rotMat(3,1) = ax(1)*ax(3)*(1-cos(t))    + ax(2)*sin(t);
rotMat(3,2) = ax(2)*ax(3)*(1-cos(t))    - ax(1)*sin(t);
rotMat(3,3) = ax(3)*ax(3)*(1-cos(t))    + cos(t);
xn = x*rotMat;
end

function f=waveElev(center,AH,w,dw,t,k,rampT,phaseRand,typeNum,waveDir)
% Function to calculate the wave elevation at an array of points
f = zeros(length(center(:,3)),1);
cx = center(:,1);
cy = center(:,2);
X = cx*cos(waveDir*pi/180) + cy*sin(waveDir*pi/180);
if typeNum <10
elseif typeNum <20
    f = AH(1).*cos(k(1).*X-w(1)*t);
elseif typeNum <30
    tmp=sqrt(AH.*dw);
    tmp1 = ones(1,length(center(:,1)));
    tmp2 = (w.*t+phaseRand)*tmp1;
    tmp3 = cos(k*X'- tmp2);
    f(:,1) = tmp3'*tmp;
end
if t<=rampT
    rampF = (1+cos(pi+pi*t/rampT))/2;
    f = f.*rampF;
end
end

== matlab function wec4/Float/Hydrodynamic Body/Structure/Motion Sensor/Angle ==
function E  = EulerAngle(Q)
% Euler Angle Type II or Tait-Bryan Angle for sequence 321 or zyx (Nautical or Cardan angles).
% Yaw [-180,180], followed by pitch [-90,90], followed by roll [-180,180]
E = zeros(3,1);
E(1) = atan2((2*(Q(1)*Q(2)+Q(3)*Q(4))),(1-2*(Q(2)^2+Q(3)^2)));
E(2) = asin(2*(Q(1)*Q(3)-Q(4)*Q(2)));
E(3) = atan2((2*(Q(1)*Q(4)+Q(2)*Q(3))),(1-2*(Q(3)^2+Q(4)^2)));

== matlab function wec4/Reactor/Hydrodynamic Body/Wave Diffraction and Excitation Force Calculation/Linear Wave Excitation Force Variant Subsystem/Irregular Wave 
Excitation Force/MATLAB Function ==
function Fext = fcn(A,w,fExtRE,fExtIM,phaseRand,dw,time)
%#codegen

% persistent A1 B1 B11 C1 D1 D11 E1 E11

A1=bsxfun(@plus,w*time,pi/2);
B1= sin(bsxfun(@plus,A1,phaseRand));
B11 = sin(bsxfun(@plus,w*time,phaseRand));
C1 = sqrt(bsxfun(@times,A,dw));
D1 =bsxfun(@times,fExtRE,C1);
D11 = bsxfun(@times,fExtIM,C1);
E1 = bsxfun(@times,B1,D1);
E11 = bsxfun(@times,B11,D11);

Fext = sum(bsxfun(@minus,E1,E11));

== matlab function wec4/Float/Hydrodynamic Body/Wave Diffraction and Excitation Force Calculation/Linear Wave Excitation Force Variant Subsystem/Irregular Wave 
Excitation Force/MATLAB Function ==
function Fext = fcn(A,w,fExtRE,fExtIM,phaseRand,dw,time)
%#codegen

% persistent A1 B1 B11 C1 D1 D11 E1 E11

A1=bsxfun(@plus,w*time,pi/2);
B1= sin(bsxfun(@plus,A1,phaseRand));
B11 = sin(bsxfun(@plus,w*time,phaseRand));
C1 = sqrt(bsxfun(@times,A,dw));
D1 =bsxfun(@times,fExtRE,C1);
D11 = bsxfun(@times,fExtIM,C1);
E1 = bsxfun(@times,B1,D1);
E11 = bsxfun(@times,B11,D11);

Fext = sum(bsxfun(@minus,E1,E11));

== matlab function wec4/Float/Hydrodynamic Body/Wave Diffraction and Excitation Force Calculation/Nonlinear FK Force Variant Subsystem/With Nonlinear FroudeKrylov Force/Diffraction and Excitation Forces ==
function [f, wp, wpMeanFS]  = nonFKForce(x,elv,center,tnorm,area,rho,g,cg,AH,w,dw,wDepth,deepWaterWave,k,typeNum,t,phaseRand)
% Function to calculate wave exitation force and moment on a triangulated surface
% NOTE: This function assumes that the STL file is imported with its CG at 0,0,0

% Logic to calculate nonFKForce at reduced sample time
[f, wp, wpMeanFS] = calc_force(x,elv,center,tnorm,area,rho,g,cg,AH,w,dw,wDepth,deepWaterWave,k,typeNum,t,phaseRand);
end

function [f, wp, wpMeanFS]  = calc_force(x,elv,center,tnorm,area,rho,g,cg,AH,w,dw,wDepth,deepWaterWave,k,typeNum,t,phaseRand)
% Function to apply translation and rotation, and calculate forces.

% Compute new tri coords after cog rotation and translation
centerMeanFS = offsetXYZ(center,cg);
avMeanFS     = tnorm .* [area area area];

% Compute new tri coords after cog rotation and translation
center = rotateXYZ(center,[1 0 0],x(4));
center = rotateXYZ(center,[0 1 0],x(5));
center = rotateXYZ(center,[0 0 1],x(6));
center = offsetXYZ(center,x);
center = offsetXYZ(center,cg);
% Compute new normal vectors coords after cog rotation and translation
tnorm = rotateXYZ(tnorm,[1 0 0],x(4));
tnorm = rotateXYZ(tnorm,[0 1 0],x(5));
tnorm = rotateXYZ(tnorm,[0 0 1],x(6));

% Copute area vectors
av = tnorm .* [area area area];

% Calculate the free surface
wpMeanFS=pDis(centerMeanFS,       0,AH,w,dw,wDepth,deepWaterWave,t,k,phaseRand,typeNum,rho,g);
wp      =pDis(center      ,     elv,AH,w,dw,wDepth,deepWaterWave,t,k,phaseRand,typeNum,rho,g);

% Calculate forces
f_linear   =FK(centerMeanFS,       cg,avMeanFS,wpMeanFS);
f_nonLinear=FK(center      ,x(1:3)+cg,av      ,wp      );
f = f_nonLinear-f_linear;
end

function verts = offsetXYZ(verts,x)
% Function to move the position vertices
verts(:,1) = verts(:,1) + x(1);
verts(:,2) = verts(:,2) + x(2);
verts(:,3) = verts(:,3) + x(3);
end

function xn = rotateXYZ(x,ax,t)
% Function to rotate a point about an arbitrary axis
% x: 3-componenet coordinates
% ax: axis about which to rotate (must be a vector length 1)
% t: rotation angle
% xn: new coordinates after rotation
rotMat = zeros(3);
rotMat(1,1) = ax(1)*ax(1)*(1-cos(t))    + cos(t);
rotMat(1,2) = ax(2)*ax(1)*(1-cos(t))    + ax(3)*sin(t);
rotMat(1,3) = ax(3)*ax(1)*(1-cos(t))    - ax(2)*sin(t);
rotMat(2,1) = ax(1)*ax(2)*(1-cos(t))    - ax(3)*sin(t);
rotMat(2,2) = ax(2)*ax(2)*(1-cos(t))    + cos(t);
rotMat(2,3) = ax(3)*ax(2)*(1-cos(t))    + ax(1)*sin(t);
rotMat(3,1) = ax(1)*ax(3)*(1-cos(t))    + ax(2)*sin(t);
rotMat(3,2) = ax(2)*ax(3)*(1-cos(t))    - ax(1)*sin(t);
rotMat(3,3) = ax(3)*ax(3)*(1-cos(t))    + cos(t);
xn = x*rotMat;
end

function f=pDis(center,elv,AH,w,dw,wDepth,deepWaterWave,t,k,phaseRand,typeNum,rho,g)
% Function to calculate pressure distribution
f = zeros(length(center(:,3)),1);
z=zeros(length(center(:,1)),1);
if typeNum <10
elseif typeNum <20
    f = rho.*g.*AH(1).*cos(k(1).*center(:,1)-w(1)*t);
    if deepWaterWave == 0
        z=(center(:,3)-elv).*wDepth./(wDepth+elv);
        f = f.*(cosh(k(1).*(z+wDepth))./cosh(k(1)*wDepth));
    else
        z=(center(:,3)-elv);
        f = f.*exp(k(1).*z);
    end
elseif typeNum <30
    for i=1:length(AH)
        if deepWaterWave == 0 && wDepth <= 0.5*pi/k(i)
            z=(center(:,3)-elv).*wDepth./(wDepth+elv);
            f_tmp = rho.*g.*sqrt(AH(i)*dw(i)).*cos(k(i).*center(:,1)-w(i)*t-phaseRand(i));
            f = f + f_tmp.*(cosh(k(i).*(z+wDepth))./cosh(k(i).*wDepth));
        else
            z=(center(:,3)-elv);
            f_tmp = rho.*g.*sqrt(AH(i)*dw(i)).*cos(k(i).*center(:,1)-w(i)*t-phaseRand(i));
            f = f + f_tmp.*exp(k(i).*z);
        end
    end
end
f(z>0)=0;
end

function f = FK(center,instcg,av,wp)
% Function to calculate the force and moment about the cog due to Froude-Krylov pressure
f = zeros(6,1);

% Calculate the hydrostatic pressure at each triangle center
pressureVect = [wp wp wp].*-av;

% Compute force about cog
f(1:3) = sum(pressureVect);

% Compute moment about cog
tmp1 = ones(length(center(:,1)),1);
tmp2 = tmp1*instcg';
center2cgVec = center-tmp2;

f(4:6)= sum(cross(center2cgVec,pressureVect));
end

== matlab function wec4/Reactor/Hydrodynamic Body/Wave Diffraction and Excitation Force Calculation/Nonlinear FK Force Variant Subsystem/With Nonlinear FroudeKrylov Force/Diffraction and Excitation Forces ==
function [f, wp, wpMeanFS]  = nonFKForce(x,elv,center,tnorm,area,rho,g,cg,AH,w,dw,wDepth,deepWaterWave,k,typeNum,t,phaseRand)
% Function to calculate wave exitation force and moment on a triangulated surface
% NOTE: This function assumes that the STL file is imported with its CG at 0,0,0

% Logic to calculate nonFKForce at reduced sample time
[f, wp, wpMeanFS] = calc_force(x,elv,center,tnorm,area,rho,g,cg,AH,w,dw,wDepth,deepWaterWave,k,typeNum,t,phaseRand);
end

function [f, wp, wpMeanFS]  = calc_force(x,elv,center,tnorm,area,rho,g,cg,AH,w,dw,wDepth,deepWaterWave,k,typeNum,t,phaseRand)
% Function to apply translation and rotation, and calculate forces.

% Compute new tri coords after cog rotation and translation
centerMeanFS = offsetXYZ(center,cg);
avMeanFS     = tnorm .* [area area area];

% Compute new tri coords after cog rotation and translation
center = rotateXYZ(center,[1 0 0],x(4));
center = rotateXYZ(center,[0 1 0],x(5));
center = rotateXYZ(center,[0 0 1],x(6));
center = offsetXYZ(center,x);
center = offsetXYZ(center,cg);
% Compute new normal vectors coords after cog rotation and translation
tnorm = rotateXYZ(tnorm,[1 0 0],x(4));
tnorm = rotateXYZ(tnorm,[0 1 0],x(5));
tnorm = rotateXYZ(tnorm,[0 0 1],x(6));

% Copute area vectors
av = tnorm .* [area area area];

% Calculate the free surface
wpMeanFS=pDis(centerMeanFS,       0,AH,w,dw,wDepth,deepWaterWave,t,k,phaseRand,typeNum,rho,g);
wp      =pDis(center      ,     elv,AH,w,dw,wDepth,deepWaterWave,t,k,phaseRand,typeNum,rho,g);

% Calculate forces
f_linear   =FK(centerMeanFS,       cg,avMeanFS,wpMeanFS);
f_nonLinear=FK(center      ,x(1:3)+cg,av      ,wp      );
f = f_nonLinear-f_linear;
end

function verts = offsetXYZ(verts,x)
% Function to move the position vertices
verts(:,1) = verts(:,1) + x(1);
verts(:,2) = verts(:,2) + x(2);
verts(:,3) = verts(:,3) + x(3);
end

function xn = rotateXYZ(x,ax,t)
% Function to rotate a point about an arbitrary axis
% x: 3-componenet coordinates
% ax: axis about which to rotate (must be a vector length 1)
% t: rotation angle
% xn: new coordinates after rotation
rotMat = zeros(3);
rotMat(1,1) = ax(1)*ax(1)*(1-cos(t))    + cos(t);
rotMat(1,2) = ax(2)*ax(1)*(1-cos(t))    + ax(3)*sin(t);
rotMat(1,3) = ax(3)*ax(1)*(1-cos(t))    - ax(2)*sin(t);
rotMat(2,1) = ax(1)*ax(2)*(1-cos(t))    - ax(3)*sin(t);
rotMat(2,2) = ax(2)*ax(2)*(1-cos(t))    + cos(t);
rotMat(2,3) = ax(3)*ax(2)*(1-cos(t))    + ax(1)*sin(t);
rotMat(3,1) = ax(1)*ax(3)*(1-cos(t))    + ax(2)*sin(t);
rotMat(3,2) = ax(2)*ax(3)*(1-cos(t))    - ax(1)*sin(t);
rotMat(3,3) = ax(3)*ax(3)*(1-cos(t))    + cos(t);
xn = x*rotMat;
end

function f=pDis(center,elv,AH,w,dw,wDepth,deepWaterWave,t,k,phaseRand,typeNum,rho,g)
% Function to calculate pressure distribution
f = zeros(length(center(:,3)),1);
z=zeros(length(center(:,1)),1);
if typeNum <10
elseif typeNum <20
    f = rho.*g.*AH(1).*cos(k(1).*center(:,1)-w(1)*t);
    if deepWaterWave == 0
        z=(center(:,3)-elv).*wDepth./(wDepth+elv);
        f = f.*(cosh(k(1).*(z+wDepth))./cosh(k(1)*wDepth));
    else
        z=(center(:,3)-elv);
        f = f.*exp(k(1).*z);
    end
elseif typeNum <30
    for i=1:length(AH)
        if deepWaterWave == 0 && wDepth <= 0.5*pi/k(i)
            z=(center(:,3)-elv).*wDepth./(wDepth+elv);
            f_tmp = rho.*g.*sqrt(AH(i)*dw(i)).*cos(k(i).*center(:,1)-w(i)*t-phaseRand(i));
            f = f + f_tmp.*(cosh(k(i).*(z+wDepth))./cosh(k(i).*wDepth));
        else
            z=(center(:,3)-elv);
            f_tmp = rho.*g.*sqrt(AH(i)*dw(i)).*cos(k(i).*center(:,1)-w(i)*t-phaseRand(i));
            f = f + f_tmp.*exp(k(i).*z);
        end
    end
end
f(z>0)=0;
end

function f = FK(center,instcg,av,wp)
% Function to calculate the force and moment about the cog due to Froude-Krylov pressure
f = zeros(6,1);

% Calculate the hydrostatic pressure at each triangle center
pressureVect = [wp wp wp].*-av;

% Compute force about cog
f(1:3) = sum(pressureVect);

% Compute moment about cog
tmp1 = ones(length(center(:,1)),1);
tmp2 = tmp1*instcg';
center2cgVec = center-tmp2;

f(4:6)= sum(cross(center2cgVec,pressureVect));
end

== matlab function wec4/Float/Non-Hydro Body/Structure/Motion Sensor/Angle ==
function E  = EulerAngle(Q)
% Euler Angle Type II or Tait-Bryan Angle for sequence 321 or zyx (Nautical or Cardan angles).
% Yaw [-180,180], followed by pitch [-90,90], followed by roll [-180,180]
E = zeros(3,1);
E(1) = atan2( (2*(Q(1)*Q(2)+Q(3)*Q(4))), (1-2* (Q(2)^2+Q(3)^2) ) );
E(2) = asin( 2* (Q(1)*Q(3) - Q(4)*Q(2)));
E(3) = atan2( (2*(Q(1)*Q(4)+Q(2)*Q(3))), (1-2* (Q(3)^2+Q(4)^2) ) );

== matlab function wec4/Reactor/Hydrodynamic Body/Wave Radiation Forces Calculation/SS CI and Constant-Damping-CoeVariant Subsystem/Convolution Integral Calculation/MATLAB Function ==
function F_FM = ConvolutionIntegral_interp(v, IRKB, lenJ, CTTime)
%#codegen
% Function to calculate convolution integral

%define persistent variables
interp_factor = 1;
persistent velocity IRKB_interp CTTime_interp;

if isempty(velocity) 
    CTTime_interp  = CTTime(1:interp_factor:end);
    velocity       = zeros(lenJ,length(CTTime_interp));
    IRKB_reordered = permute(IRKB,[3 1 2]);                     % permutes from [601 6 12] to [12 601 6]
    IRKB_interp    = IRKB_reordered(:,1:interp_factor:end, :);  % what does this do?
end 
% shift velocity
velocity      = circshift(velocity, 1, 2);
v = v(:)'';           %force v to be a column
velocity(:,1) = v(:);

%integrate
time_series = bsxfun(@times, IRKB_interp, velocity);
F_FM = squeeze(trapz(CTTime_interp,sum(time_series, 1)));

end

== matlab function wec4/Reactor/Non-Hydro Body/Structure/Motion Sensor/Angle ==
function E  = EulerAngle(Q)
% Euler Angle Type II or Tait-Bryan Angle for sequence 321 or zyx (Nautical or Cardan angles).
% Yaw [-180,180], followed by pitch [-90,90], followed by roll [-180,180]
E = zeros(3,1);
E(1) = atan2( (2*(Q(1)*Q(2)+Q(3)*Q(4))), (1-2* (Q(2)^2+Q(3)^2) ) );
E(2) = asin( 2* (Q(1)*Q(3) - Q(4)*Q(2)));
E(3) = atan2( (2*(Q(1)*Q(4)+Q(2)*Q(3))), (1-2* (Q(3)^2+Q(4)^2) ) );

== matlab function wec4/PTO P4F4/PTO P4F4 visu/Hydrodynamic Body/Hydrostatic Restoring Force Calculation/Linear and Nonlinear Restoring Force Variant Subsystem/Nonlinear Hydrostatic Restoring Force/Restoring Forces ==
function [f,p]  = nonLinearBuoyancy(x,elv,center,tnorm,area,rho,g,cg,mass)
% Function to calculate buoyancy force and moment on a triangulated surface
% NOTE: This function assumes that the STL file is imported with its CG at 0,0,0
[f,p] = calc_buoyancy(x,elv,center,tnorm,area,rho,g,cg);
f = -f + [0 0 g*mass 0 0 0]';
end


function [f,p] = calc_buoyancy(x,elv,center,tnorm,area,rho,g,cg)
% Function to apply translation and rotation and calculate forces

% Compute new tri coords after cog rotation and translation
center = rotateXYZ(center,[1 0 0],x(4));
center = rotateXYZ(center,[0 1 0],x(5));
center = rotateXYZ(center,[0 0 1],x(6));
center = offsetXYZ(center,x);
center = offsetXYZ(center,cg);
% Compute new normal vectors coords after cog rotation
tnorm = rotateXYZ(tnorm,[1 0 0],x(4));
tnorm = rotateXYZ(tnorm,[0 1 0],x(5));
tnorm = rotateXYZ(tnorm,[0 0 1],x(6));

% Calculate the hydrostatic forces
av = tnorm .* [area area area];
[f,p]=fHydrostatic(center,elv,x(1:3)+cg,av,rho,g);
end

function verts = offsetXYZ(verts,x)
% Function to move the position vertices
verts(:,1) = verts(:,1) + x(1);
verts(:,2) = verts(:,2) + x(2);
verts(:,3) = verts(:,3) + x(3);
end

function xn = rotateXYZ(x,ax,t)
% Function to rotate a point about an arbitrary axis
% x: 3-componenet coordiantes
% ax: axis about which to rotate (must be a vector length 1)
% t: rotation angle
% xn: new coordinates after rotation
rotMat = zeros(3);
rotMat(1,1) = ax(1)*ax(1)*(1-cos(t))    + cos(t);
rotMat(1,2) = ax(2)*ax(1)*(1-cos(t))    + ax(3)*sin(t);
rotMat(1,3) = ax(3)*ax(1)*(1-cos(t))    - ax(2)*sin(t);
rotMat(2,1) = ax(1)*ax(2)*(1-cos(t))    - ax(3)*sin(t);
rotMat(2,2) = ax(2)*ax(2)*(1-cos(t))    + cos(t);
rotMat(2,3) = ax(3)*ax(2)*(1-cos(t))    + ax(1)*sin(t);
rotMat(3,1) = ax(1)*ax(3)*(1-cos(t))    + ax(2)*sin(t);
rotMat(3,2) = ax(2)*ax(3)*(1-cos(t))    - ax(1)*sin(t);
rotMat(3,3) = ax(3)*ax(3)*(1-cos(t))    + cos(t);
xn = x*rotMat;
end

function [f,p] = fHydrostatic(center,elv,instcg,av,rho,g)
% Function to calculate the force and moment about the cog due to hydrostatic pressure
f = zeros(6,1);

% Zeor out regions above the mean free surface
z=center(:,3); z((z-elv)>0)=0;

% Calculate the hydrostatic pressure at each triangle center
pressureVect = rho*g.*[-z -z -z].*-av;
p = rho*g.*-z;
% Compute force about cog
f(1:3) = sum(pressureVect);

tmp1 = ones(length(center(:,1)),1);
tmp2 = tmp1*instcg';
center2cgVec = center-tmp2;

f(4:6)= sum(cross(center2cgVec,pressureVect));
end

== matlab function wec4/PTO P4F4/PTO P4F4 visu/Hydrodynamic Body/Morrison Element and ViscousDampingForceCalculation/Morrison Element Variant Subsystem/Morrison Element On/Irregular Wave 
Morison Force/MorrisonElements/MorisonElementIrregular/MATLAB Function ==
function [u,v,w,xa,ya,za] = calc_orbital_vel(disp, waveNumber, waveFreq, waveAmp, phase, time, rampT, waveDir, waterDepth, g)
%#codegen

[u,v,w,xa,ya,za] = orbital_velocity(disp, waveNumber, waveFreq, waveAmp, phase, time, rampT, waveDir, waterDepth, g);

== matlab function wec4/PTO P4F4/PTO P4F4 visu/Hydrodynamic Body/Morrison Element and ViscousDampingForceCalculation/Morrison Element Variant Subsystem/Morrison Element On/Regular Wave 
Morison Force/MorrisonElements/OrbitalVelocity/MATLAB Function ==
function [u,v,w,xa,ya,za] = calc_orbital_vel(disp, waveNumber, waveFreq, waveAmp, randPhase, time, rampT, waveDir, waterDepth, g)
%#codegen

[u,v,w,xa,ya,za] = orbital_velocity(disp, waveNumber, waveFreq, waveAmp, randPhase, time, rampT, waveDir, waterDepth, g);

== matlab function wec4/PTO P4F4/PTO P4F4 visu/Hydrodynamic Body/Nonlinear Wave Elevation/Linear or Instantaneous Free Surface/Instantaneous Water Free Surface  /Instantaneous FS ==
function f  = waveElevation(x,center,cg,AH,w,dw,k,typeNum,t,rampT,phaseRand,waveDir)
% Function to calculate the wave elevation at the ceontroids of triangulated surface
% NOTE: This function assumes that the STL file is imported with its CG at 0,0,0
f = calc_elev(x,center,cg,AH,w,dw,k,typeNum,t,rampT,phaseRand, waveDir);
end

function f = calc_elev(x,center,cg,AH,w,dw,k,typeNum,t,rampT,phaseRand,waveDir)
% Function to rotate and translate body and call wave elevation function at new locations

% Compute new tri center coords after cog rotation and translation
center = rotateXYZ(center,[1 0 0],x(4));
center = rotateXYZ(center,[0 1 0],x(5));
center = rotateXYZ(center,[0 0 1],x(6));
center = offsetXYZ(center,x);
center = offsetXYZ(center,cg);
% Calculate the free surface
f=waveElev(center,AH,w,dw,t,k,rampT,phaseRand,typeNum,waveDir);
end

function verts = offsetXYZ(verts,x)
% Function to move the position vertices
verts(:,1) = verts(:,1) + x(1);
verts(:,2) = verts(:,2) + x(2);
verts(:,3) = verts(:,3) + x(3);
end

function xn = rotateXYZ(x,ax,t)
% Function to rotate a point about an arbitrary axis
% x: 3-component coordinates
% ax: axis about which to rotate (must be a vector length 1)
% t: rotation angle
% xn: new coordinates after rotation
rotMat = zeros(3);
rotMat(1,1) = ax(1)*ax(1)*(1-cos(t))    + cos(t);
rotMat(1,2) = ax(2)*ax(1)*(1-cos(t))    + ax(3)*sin(t);
rotMat(1,3) = ax(3)*ax(1)*(1-cos(t))    - ax(2)*sin(t);
rotMat(2,1) = ax(1)*ax(2)*(1-cos(t))    - ax(3)*sin(t);
rotMat(2,2) = ax(2)*ax(2)*(1-cos(t))    + cos(t);
rotMat(2,3) = ax(3)*ax(2)*(1-cos(t))    + ax(1)*sin(t);
rotMat(3,1) = ax(1)*ax(3)*(1-cos(t))    + ax(2)*sin(t);
rotMat(3,2) = ax(2)*ax(3)*(1-cos(t))    - ax(1)*sin(t);
rotMat(3,3) = ax(3)*ax(3)*(1-cos(t))    + cos(t);
xn = x*rotMat;
end

function f=waveElev(center,AH,w,dw,t,k,rampT,phaseRand,typeNum,waveDir)
% Function to calculate the wave elevation at an array of points
f = zeros(length(center(:,3)),1);
cx = center(:,1);
cy = center(:,2);
X = cx*cos(waveDir*pi/180) + cy*sin(waveDir*pi/180);
if typeNum <10
elseif typeNum <20
    f = AH(1).*cos(k(1).*X-w(1)*t);
elseif typeNum <30
    tmp=sqrt(AH.*dw);
    tmp1 = ones(1,length(center(:,1)));
    tmp2 = (w.*t+phaseRand)*tmp1;
    tmp3 = cos(k*X'- tmp2);
    f(:,1) = tmp3'*tmp;
end
if t<=rampT
    rampF = (1+cos(pi+pi*t/rampT))/2;
    f = f.*rampF;
end
end

== matlab function wec4/PTO P4F4/PTO P4F4 visu/Hydrodynamic Body/Structure/Motion Sensor/Angle ==
function E  = EulerAngle(Q)
% Euler Angle Type II or Tait-Bryan Angle for sequence 321 or zyx (Nautical or Cardan angles).
% Yaw [-180,180], followed by pitch [-90,90], followed by roll [-180,180]
E = zeros(3,1);
E(1) = atan2((2*(Q(1)*Q(2)+Q(3)*Q(4))),(1-2*(Q(2)^2+Q(3)^2)));
E(2) = asin(2*(Q(1)*Q(3)-Q(4)*Q(2)));
E(3) = atan2((2*(Q(1)*Q(4)+Q(2)*Q(3))),(1-2*(Q(3)^2+Q(4)^2)));

== matlab function wec4/PTO P4F4/PTO P4F4 visu/Hydrodynamic Body/Wave Diffraction and Excitation Force Calculation/Linear Wave Excitation Force Variant Subsystem/Irregular Wave 
Excitation Force/MATLAB Function ==
function Fext = fcn(A,w,fExtRE,fExtIM,phaseRand,dw,time)
%#codegen

% persistent A1 B1 B11 C1 D1 D11 E1 E11

A1=bsxfun(@plus,w*time,pi/2);
B1= sin(bsxfun(@plus,A1,phaseRand));
B11 = sin(bsxfun(@plus,w*time,phaseRand));
C1 = sqrt(bsxfun(@times,A,dw));
D1 =bsxfun(@times,fExtRE,C1);
D11 = bsxfun(@times,fExtIM,C1);
E1 = bsxfun(@times,B1,D1);
E11 = bsxfun(@times,B11,D11);

Fext = sum(bsxfun(@minus,E1,E11));
